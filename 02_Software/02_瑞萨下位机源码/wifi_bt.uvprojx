# Keil uVision project wifi_bt.uvprojx, settings and files
target Target 1 (6190000::V6.19::C:\Keil_v5\ARM\ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: wifi_bt +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\applications;.\devices;.\drivers;.\include;.\libs;.\ra;.\devices\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Applications
    ./applications/: app_wifi_bt.c app_adc.c app_dht11.c app_BH1750.c app_disp.c app_pwm.c kalman.c
    ./include/: config.h
  group Devices/Modules
    ./devices/wifi_bluetooth/: dev_wifi_bt.c
    ./devices/DHT11/: dev_dht11.c
    ./devices/ADC/: dev_PH.c dev_MH.c dev_MQ.c
    ./devices/LCD/: dev_lcd.c font.h
    ./devices/GY_302/: dev_bh1750_1.c dev_bh1750_1.h
  group Devices
    ./devices/: dev_uart.c dev_timer.c dev_gpio.c dev_adc.c
  group Drivers
    ./drivers/: drv_uart.c drv_systick.c drv_gpt.c drv_gpio.c drv_adc.c drv_gpt_pwm.c drv_bh1750_iic.c drv_bh1750_iic.h
  group Libs
    ./libs/delay/: delay.c
    ./libs/ring_buffer/: ring_buffer.c
    ./libs/printf/: printf.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
